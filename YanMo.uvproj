# Keil uVision project YanMo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: YanMo +hex
  c flags: SizeSpeed=1
  c include: .\Common;.\Include
  group Source Group 1
    ./: STARTUP.A51 YanMo.C Uart.c Key.c EEPROM.c PWM.c Display.c counter.c PID.c
