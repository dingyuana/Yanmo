# Keil uVision project SmartM.uvproj, settings and files
target UART (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: SmartM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Common;..\Include
  group MAIN
    ./: main.c STARTUP.A51 EEPROM.c Uart.c
    ../Common/: Common.c
  group LCD
    ./: LCD.c
  group SPI
    ./: Spi.c
  group FLASH
    ./: Flash.c
  group LED
    ./: Led.c
